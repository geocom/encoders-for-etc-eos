# Repository geocom/encoders-for-etc-eos

File README.md:

# Work in Progress
This fork is doing the following;
Done and tested
   - Changing PCB design to use standard Gateron keys instead of the very costly buttons on older versions.
   - Flips teensy to be under mounted as the top mounted has some design trade off's due to the switch change this is also a functional requirement due to the components under the teensy 4.0's pcb that were not there on teensy 3.2's. Leaving it on top would have resulted in a height change on the front. Given that 3D printing is cheap and commonplace and bottom mounting can allow for better integration options and lets you use headers so you can quickly repair the device.
   - Change teensy 3.2(discontinued) pin mapping to be teensy 4.0 compatible (most of this has been done by dropping the buttons)
   - Adds symbols for similar resistors and caps making it easier to solder
Semi done
   - Software rewrite has been done and will be in a separate repo once board tested(this is a complete rewrite using arduino and more generic packages, the build in this repo is locked to teensy 3.2) it needs modifications based on this board as current testing has been done on a bodged(to work with teensy 4.0) rev b board without the extra WS2812(on the rev c board) for the keys so needs a bit more rewriting
To Do
   - 3D files mid board and mounting plate to do
   - Fully validate PCB by ordering and making [Done]

# Encoders for ETC Eos

A 9-encoder (un-official) add on to the [ETC Eos][etceos] Family of Lighting Consoles and Software, using OSC over USB.

This is an independent project that is designed to work with the [ETC Eos][etceos], but not affiliated with Electronic Theatre Controls in any way.

- [Encoders for ETC Eos](#encoders-for-etc-eos)
  - [Quick Start](#quick-start)
  - [Usage](#usage)
    - [Status LEDs](#status-leds)
    - [Page Select Buttons](#page-select-buttons)
    - [Auxilary Buttons](#auxilary-buttons)
  - [Compatibility](#compatibility)
  - [Contributing](#contributing)
  - [Credits](#credits)
  - [License](#license)

## Quick Start

*To build the hardware, consult the README located in the [Hardware](Hardware/README.md) folder.*\
*To make changes to the firmware, consult the README located in the [Firmware](Firmware/README.md) folder.*

1. Connect the encoders to your console, PC or Mac using a USB-A to micro-USB cable.
2. Start up the ETCnomad software or Eos family console.
3. Navigate to Settings > System > Show Control > OSC in the software, and ensure OSC USB is enabled.\
   
4. Reboot the console or restart the software.
5. The left-hand status indicator on the encoders should change from orange (not connected) to green (connected).
6. Select a channel in the Eos console or ETCnomad software, the encoders will update with any parameters applicable to the selected page.
7. Select the page to adjust desired parameters:\
    
   - 1st (red) button: Intensity, focus and beam parameters
   - 2nd (amber) button: Colour parameters (press multiple times to switch between the 3 layouts).
   - 3rd (green) button: Not used - for future use.
   - 4th (blue) button: Framing shutters
8. Adjust parameters by spinning the encoder clockwise or anti-clockwise. A fine mode can be toggled on or off by pushing the encoder in.\

## Usage

The Encoders consist of the following components:

- 9x Encoders each with integrated push-button, a small 10x2 display and RGB LED
- 4x Page-select buttons in red, amber, green and blue.
- 2x Auxilary buttons for future use.
- 3x Auxilary RGB LEDs for status feedback and future use.
- 1x Micro-USB socket for connection to the console, PC or Mac.
- 512kB of memory for future use, such as storing custom user configuration of page layouts.

### Status LEDs

The three RGB LEDs on the right-hand side of the provide some basic functionality feedback:

- The left-hand LED is orange when not connected to any Eos software or console, green when connected.
- The middle LED is not used, reserved for future use.
- The right-hand LED flashes a dim cyan at 1Hz to indicate the encoder firmware is still running its main loop (for debugging purposes).

### Page Select Buttons

The four page select buttons allow the user to choose the group of parameters they wish to adjust:

1. The first (red) button has a single layout for intensity, focus and beam adjustments:\
   
2. The second (amber) button has three layouts for colour adjustments:
   1. CMY Layout:\
      
   2. RGB / x7 Layout:\
      
   3. x7 Adjust Layout:\
      
3. The third (green) button currently has no layout and is for future use.
4. The fourth (blue) button has one layout for framing shutter adjustments:\

### Auxilary Buttons

The two circular buttons on the right hand side are currently not used and reserved for future use.

## Compatibility

The encoders will not work on any Win XPe-based consoles. It should work on any Win 7e-based Eos consoles, as well as any version of the ETCnomad software that supports OSC-over-USB. See the [ETC Lighthack GitHub][lighthack] page:
> Eos supports this functionality on Win7e-based consoles and ETCnomad for Windows in software version 2.6.1 and newer, and on ETCnomad for Mac in software version 2.7.0 and newer.
>
> *Support for XPe-based consoles or XP computers is not planned for this project. Many XPe-based consoles can be upgraded to Win7e to make them compatible with #lighthack.*

As the Lighthack project was intended for the Arduino Uno (and this project uses a Teensy 3.2), the USB Vendor ID and Product ID had to be spoofed so the encoder board looks like an Arduino instead of a Teensy. Eos consoles will ignore OSC messages from USB devices that do not have the Arduino Uno Vendor ID and Product ID.

## Contributing

Contributions are most welcome!
Please log an issue and/or pull request for any bugs or feature changes you may wish to share.

## Credits

[ETC LightHack][lighthack] which formed the basis and initial inspiration for this project

## License

All hardware files (inside `Hardware`) and original source code (inside `Firmware/src`) uses the Apache 2.0 license. See [LICENSE](LICENSE) for more information.

Libraries inside `Firmare/lib` and `Firmware/core` have been licensed separately by their respective authors and include a mixture of BSD, MIT, public domain, LGPLv2 and other licenses. More information on each can be found in the relevant source files.

[lighthack]: https://github.com/ETCLabs/lighthack
[etceos]: https://www.etcconnect.com/Products/Consoles/Eos-Family/

## KiCad design Hardware/EncoderBoard.kicad_pcb

Board: 2 copper layers, 243.7 x 61.0 mm, 228 parts (156 on the bottom side), 141 nets.

Parts:
C1, C3, C5, C7, C9, C10, C14, C15, C18, C19, C20, C25, C26, C27, C28, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C45, C46, C47, C52, C53, C54, C57, C58, C59, C60, C61, C62, C63, C64, C65, C66, C67, C68, C69, C70, C71, C72, C73, C74, C75: 100nF; C_0805_2012Metric
C2, C4, C6, C8, C11: 10uF; C_1210_3225Metric
C12, C13, C16, C17, C21, C22, C23, C24, C29, C42, C43, C44, C48, C49, C50, C51, C55, C56: 10nF; C_0805_2012Metric
C76, C78, C79, C80, C81: 0.1uf; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C77: C; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
H1, H2, H3, H4, H5: MountingHole; MountingHole_3.2mm_M3
K1, K2, K3, K4, K5, K6: key; SW_Cherry_MX_1.00u_Plate
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R18, R19, R20, R21, R88, R89: 4.7k; R_0805_2012Metric
R17: 330R; R_0805_2012Metric
R22, R23, R24, R25, R27, R28, R29, R30, R32, R33, R34, R35, R36, R37, R39, R40, R42, R43, R44, R45, R46, R47, R49, R50, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R65, R66, R67, R68, R69, R70, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R87, R90, R91, R92, R93, R94, R95: 10k; R_0805_2012Metric
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9: Rotary_Encoder_Switch; RotaryEncoder_Bourns_PEC12R-4x20k-Sxxxx-Switch_Vertical_H20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
U1, U2, U3: MCP23S17_SO; SOIC-28W_7.5x17.9mm_P1.27mm
U4, U6: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm
U5: 74HCT245; TSSOP-20_4.4x6.5mm_P0.65mm
U7: Teensy3.2; Teensy30_31_32_LC
U8, U24, U25, U26: CAT24M01W; SOIC-8_3.9x4.9mm_P1.27mm
U9, U10, U11, U12, U13, U14, U15, U16, U17: Display_OLED_128x32_I2C
U18, U19, U20, U21, U22, U23: 74LVC14; SOIC-14_3.9x8.7mm_P1.27mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C10.1, C11.1, C57.1, C58.1, C59.1, C60.1, C61.1, C62.1, C63.1, C64.1, C65.1, C66.1, C67.1, C68.1, C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C75.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R25.1, R28.1, R30.1, R32.1, R39.1, R40.1, R43.1, R44.1, R45.1, R46.1, R55.1, R56.1, R58.1, R59.1, R60.1, R61.1, R69.1, R70.1, R71.1, R73.1, R74.1, R75.1, R82.1, R83.1, R84.1, R88.1, R89.1, R90.1, R91.1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
+5V: C9.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C76.2, C77.1, C78.1, C79.2, C80.1, C81.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), K1.6 (VCC), K2.6 (VCC), K3.6 (VCC), K4.6 (VCC), K5.6 (VCC), K6.6 (VCC), U5.1 (A->B), U5.20 (VCC), U7.33 (Vin)
/WS2812_3V3: U5.2 (A0), U7.3 (1_TX1_Touch)
BUTTON0_SW: U3.7 (GPB6), U22.2
BUTTON1_SW: U3.8 (GPB7), U22.4
BUTTON2_SW: U3.24 (GPA3), U23.2
BUTTON3_SW: U3.23 (GPA2), U23.4
BUTTON4_SW: U3.22 (GPA1), U23.6
BUTTON5_SW: U3.21 (GPA0), U23.8
CS0: U1.11 (~CS), U2.11 (~CS), U3.11 (~CS), U7.12 (10_TX2_CS_PWM)
EEPROM_WP: U7.4 (2), U8.7 (WP), U24.7 (WP), U25.7 (WP), U26.7 (WP)
ENC0_A: U1.25 (GPA4), U18.10
ENC0_B: U1.26 (GPA5), U18.8
ENC0_SW: U1.27 (GPA6), U18.12
ENC1_A: U1.1 (GPB0), U18.6
ENC1_B: U1.2 (GPB1), U18.4
ENC1_SW: U1.3 (GPB2), U18.2
ENC2_A: U2.25 (GPA4), U19.10
ENC2_B: U2.26 (GPA5), U19.8
ENC2_SW: U2.27 (GPA6), U19.12
ENC3_A: U2.1 (GPB0), U19.6
ENC3_B: U2.2 (GPB1), U19.4
ENC3_SW: U2.3 (GPB2), U19.2
ENC4_A: U1.21 (GPA0), U20.10
ENC4_B: U1.22 (GPA1), U20.8
ENC4_SW: U1.23 (GPA2), U20.12
ENC5_A: U1.5 (GPB4), U20.6
ENC5_B: U1.6 (GPB5), U20.4
ENC5_SW: U1.7 (GPB6), U20.2
ENC6_A: U2.21 (GPA0), U21.10
ENC6_B: U2.22 (GPA1), U21.8
ENC6_SW: U2.23 (GPA2), U21.12
ENC7_A: U2.5 (GPB4), U21.6
ENC7_B: U2.6 (GPB5), U21.4
ENC7_SW: U2.7 (GPB6), U21.2
ENC8_A: U3.25 (GPA4), U22.10
ENC8_B: U3.26 (GPA5), U22.8
ENC8_SW: U3.27 (GPA6), U22.12
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.2, C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C68.2, C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C75.2, C76.1, C77.2, C78.2, C79.1, C80.2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
INT0_A: U1.20 (INTA), U7.9 (7_RX3_DOUT)
INT1_A: U2.20 (INTA), U7.10 (8_TX3_DIN)
INT2_A: U3.20 (INTA), U7.11 (9_RX2_CS_PWM)
KEY_WS_DATA: D12.2 (DOUT), K1.4 (DIN)
MISO: U1.14 (SO), U2.14 (SO), U3.14 (SO), U7.14 (12_DIN)
MOSI: U1.13 (SI), U2.13 (SI), U3.13 (SI), U7.13 (11_DOUT)
unnamed: C12.1, R27.2, U18.11
unnamed: C13.1, R29.2, U18.9
unnamed: C14.1, R33.1, U18.13
unnamed: C15.1, R34.1, U20.1
unnamed: C16.1, R24.2, U20.5
unnamed: C17.1, R35.2, U20.3
unnamed: C18.1, R36.1, U22.1
unnamed: C19.1, R47.1, U18.1
unnamed: C20.1, R49.1, U21.13
unnamed: C21.1, R37.2, U18.5
unnamed: C22.1, R50.2, U18.3
unnamed: C23.1, R42.2, U21.11
unnamed: C24.1, R52.2, U21.9
unnamed: C25.1, R53.1, U22.3
unnamed: C26.1, R62.1, U19.13
unnamed: C27.1, R63.1, U21.1
unnamed: C28.1, R64.1, U23.1
unnamed: C29.1, R54.2, U19.11
unnamed: C42.1, R65.2, U19.9
unnamed: C43.1, R57.2, U21.5
unnamed: C44.1, R66.2, U21.3
unnamed: C45.1, R67.1, U23.3
unnamed: C46.1, R76.1, U19.1
unnamed: C47.1, R77.1, U22.13
unnamed: C48.1, R68.2, U19.5
unnamed: C49.1, R78.2, U19.3
unnamed: C50.1, R72.2, U22.11
unnamed: C51.1, R79.2, U22.9
unnamed: C52.1, R80.1, U23.5
unnamed: C53.1, R85.1, U20.13
unnamed: C54.1, R86.1, U23.9
unnamed: C55.1, R81.2, U20.11
unnamed: C56.1, R87.2, U20.9
unnamed: K1.5 (DOUT), K2.4 (DIN)
unnamed: K1.2, R36.2, R90.2
unnamed: K2.5 (DOUT), K3.4 (DIN)
unnamed: K2.2, R53.2, R91.2
unnamed: K3.5 (DOUT), K4.4 (DIN)
unnamed: K3.2, R64.2, R92.2
unnamed: K4.5 (DOUT), K5.4 (DIN)
unnamed: K4.2, R67.2, R93.2
unnamed: K5.5 (DOUT), K6.4 (DIN)
unnamed: K5.2, R80.2, R94.2
unnamed: K6.2, R86.2, R95.2
unnamed: R22.2, R27.1, SW1.A
unnamed: R23.2, R29.1, SW1.B
unnamed: R24.1, R25.2, SW6.A
unnamed: R28.2, R35.1, SW6.B
unnamed: R30.2, R33.2, SW1.S1
unnamed: R32.2, R34.2, SW6.S1
unnamed: R37.1, R39.2, SW2.A
unnamed: R40.2, R50.1, SW2.B
unnamed: R42.1, R43.2, SW7.A
unnamed: R44.2, R52.1, SW7.B
unnamed: R45.2, R47.2, SW2.S1
unnamed: R46.2, R49.2, SW7.S1
unnamed: R54.1, R55.2, SW3.A
unnamed: R56.2, R65.1, SW3.B
unnamed: R57.1, R58.2, SW8.A
unnamed: R59.2, R66.1, SW8.B
unnamed: R60.2, R62.2, SW3.S1
unnamed: R61.2, R63.2, SW8.S1
unnamed: R68.1, R69.2, SW4.A
unnamed: R70.2, R78.1, SW4.B
unnamed: R71.2, R76.2, SW4.S1
unnamed: R72.1, R73.2, SW9.A
unnamed: R74.2, R79.1, SW9.B
unnamed: R75.2, R77.2, SW9.S1
unnamed: R81.1, R82.2, SW5.A
unnamed: R83.2, R87.1, SW5.B
unnamed: R84.2, R85.2, SW5.S1
unnamed: R88.2, U4.3 (~RESET)
unnamed: R17.2, U5.18 (B0)
unnamed: R89.2, U6.3 (~RESET)
SCL: R21.2, U4.22 (SCL), U6.22 (SCL), U7.26 (19_A5_SCL0_Touch), U8.6 (SCL), U24.6 (SCL), U25.6 (SCL), U26.6 (SCL)
SCL0: R1.2, U4.5 (SC0), U9.2 (SCL)
SCL1: R3.2, U4.7 (SC1), U10.2 (SCL)
SCL2: R5.2, U4.18 (SC6), U11.2 (SCL)
SCL3: R7.2, U6.5 (SC0), U12.2 (SCL)
SCL4: R9.2, U4.9 (SC2), U13.2 (SCL)
SCL5: R11.2, U4.14 (SC4), U14.2 (SCL)
SCL6: R13.2, U4.16 (SC5), U15.2 (SCL)
SCL7: R15.2, U6.7 (SC1), U16.2 (SCL)
SCL8: R18.2, U6.14 (SC4), U17.2 (SCL)
SCLK: U1.12 (SCK), U2.12 (SCK), U3.12 (SCK), U7.20 (13_LED_SCK)
SDA: R20.2, U4.23 (SDA), U6.23 (SDA), U7.25 (18_A4_SDA0_Touch), U8.5 (SDA), U24.5 (SDA), U25.5 (SDA), U26.5 (SDA)
SDA0: R2.2, U4.4 (SD0), U9.1 (SDA)
SDA1: R4.2, U4.6 (SD1), U10.1 (SDA)
SDA2: R6.2, U4.17 (SD6), U11.1 (SDA)
SDA3: R8.2, U6.4 (SD0), U12.1 (SDA)
SDA4: R10.2, U4.8 (SD2), U13.1 (SDA)
SDA5: R12.2, U4.13 (SD4), U14.1 (SDA)
SDA6: R14.2, U4.15 (SD5), U15.1 (SDA)
SDA7: R16.2, U6.6 (SD1), U16.1 (SDA)
SDA8: R19.2, U6.13 (SD4), U17.1 (SDA)
WS2812_DATA: D1.4 (DIN), R17.1

## Commit log

2024-07-27 Progress push Rev C PCB
    Change Buttons to Gateron/Cherry MX and WS2812 as part of key
    Teensy 4.0 Compatible design / Under mount Teensy
    Update Read Me with work in progress list
    Add symbols to PCB with common values for easier soldering
2024-08-30 Update README.md
    PCB tested and works will likely update some silkscreen icons as there are a few missing and combine the caps for the LED's so they show as the same item in a BOM export
